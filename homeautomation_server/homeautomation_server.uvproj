# Keil uVision project homeautomation_server.uvproj, settings and files
target mbed FRDM-KL25Z (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: homeautomation_server
  AfterMake: fromelf --bin -o build\homeautomation_server_KL25Z.bin build\homeautomation_server.axf
  c flags: Optim=1
  c define: TARGET_KL25Z,  TARGET_M0P,  TARGET_CORTEX_M,  TARGET_Freescale,  TARGET_KLXX,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M0PLUS,  ARM_MATH_CM0PLUS,  MBED_BUILD_TIMESTAMP=1419017689.95,  __MBED__=1,  TARGET_FF_ARDUINO,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  mbed;  mbed/TARGET_KL25Z;  mbed/TARGET_KL25Z/TARGET_Freescale;  mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX;  mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z;  mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD;  NVIC_set_all_priorities;  HTTPClient;  HTTPClient/data;  cc3000_hostdriver_mbedsocket;  cc3000_hostdriver_mbedsocket/Socket;  cc3000_hostdriver_mbedsocket/Helper;  SDFileSystem;  SDFileSystem/FATFileSystem;  SDFileSystem/FATFileSystem/ChaN;
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  link misc: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/startup_MKL25Z4.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/mbed_overrides.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/system_MKL25Z4.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    ./: main.cpp init.cpp
    NVIC_set_all_priorities/: NVIC_set_all_priorities.cpp
    HTTPClient/: HTTPClient.cpp
    HTTPClient/data/: HTTPText.cpp HTTPMap.cpp
    cc3000_hostdriver_mbedsocket/: cc3000_event.cpp cc3000_hci.cpp cc3000_netapp.cpp cc3000_simplelink.cpp cc3000_spi.cpp cc3000.cpp cc3000_wlan.cpp cc3000_security.cpp cc3000_nvmem.cpp cc3000_socket.cpp
    cc3000_hostdriver_mbedsocket/Socket/: Socket.cpp UDPSocket.cpp Endpoint.cpp TCPSocketConnection.cpp TCPSocketServer.cpp
    SDFileSystem/: SDFileSystem.cpp
    SDFileSystem/FATFileSystem/: FATDirHandle.cpp FATFileHandle.cpp FATFileSystem.cpp
    SDFileSystem/FATFileSystem/ChaN/: ccsbcs.cpp ff.cpp diskio.cpp
